## boards/native_sim.conf
```kconfig
CONFIG_DISPLAY=y
CONFIG_SDL_DISPLAY_ZOOM_PCT=600
CONFIG_NATIVE_SIM_SLOWDOWN_TO_REAL_TIME=y
CONFIG_SDL_DISPLAY_MONO_VTILED=y
```
